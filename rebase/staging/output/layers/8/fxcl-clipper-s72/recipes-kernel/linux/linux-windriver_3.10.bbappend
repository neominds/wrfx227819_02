require linux-windriver-fxcl-clipper-s72.inc
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "file://fxcl-clipper-s72-standard.scc"
